# Keil uVision project dht_lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: dht_lcd1602 +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c LCD1602.c
